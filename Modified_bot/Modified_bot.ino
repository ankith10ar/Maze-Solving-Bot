    #define vel_motor_right 10  
    #define vel_motor_left 11          
    #define e1 8  
    #define e2 9  
    #define d1 12  
    #define d2 7  
 
    int trigger_front = A4; 
    int echo_front = A5; 
    int trigger_right = A2;
    int echo_right = A3;
    int trigger_left = A0;
    int echo_left = A1;
    
    void setup()
    {
        pinMode(trigger_front, OUTPUT); 
        pinMode(echo_front, INPUT);
        
        pinMode(trigger_right, OUTPUT);
        pinMode(echo_right, INPUT);        
        
        pinMode(trigger_left, OUTPUT);
        pinMode(echo_left, INPUT);
       
        pinMode(vel_motor_right, OUTPUT);
        pinMode(vel_motor_right, OUTPUT);
     
        pinMode(e1, OUTPUT);
        pinMode(e2, OUTPUT);
        pinMode(d1, OUTPUT);
        pinMode(d2, OUTPUT);      
        delay(5000);
    }
    
 
    void loop()
    {
   
     long dur_front, dur_right, dur_left, left, right, front; 
     
     
     digitalWrite(trigger_front, LOW);  
     delayMicroseconds(2);               
     digitalWrite(trigger_front, HIGH); 
     delayMicroseconds(5);               
     digitalWrite(trigger_front, LOW);  
     dur_front = pulseIn(echo_front, HIGH); 
     front = dur_front/29/2;
    
     digitalWrite(trigger_right, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_right, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_right, LOW); 
     dur_right = pulseIn(echo_right, HIGH);
     right = dur_right/29/2;
    
     digitalWrite(trigger_left, LOW);
     delayMicroseconds(2);
     digitalWrite(trigger_left, HIGH);
     delayMicroseconds(5);
     digitalWrite(trigger_left, LOW); 
     dur_left = pulseIn(echo_left, HIGH);
     left = dur_left/29/2; 
     
     analogWrite(vel_motor_right, 0);  
     analogWrite(vel_motor_right, 0); 
     analogWrite(e1, 0);            
     analogWrite(e2, 0);              
     analogWrite(d1, 0);            
     analogWrite(d2, 0);            
     
       if(front >8) 
         {    
           
           if(left >7 && left< 13) 
             {               
               analogWrite(vel_motor_right, 120);
               analogWrite(vel_motor_left, 150);
           
               analogWrite(e1, 255);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 255);                                                        
             }
         
           if(left >=13)  
             {
               analogWrite(vel_motor_right, 255);
               analogWrite(vel_motor_left, 60);
           
               analogWrite(e1, 255);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 255);                               
             }
             
                 
           if(left <=7)   
             {
               analogWrite(vel_motor_right, 60);
               analogWrite(vel_motor_left, 255);
           
               analogWrite(e1, 255);
               analogWrite(e2, 0);
               analogWrite(d1, 0);
               analogWrite(d2, 255);                   
             }
         }
         
              
       if(right <=20 && left >20 && front <=8) dir();   
            
       if(right >20 && left >20 && front <=8) dir(); 
       
       if(left <=20 && right >20 && front <=8) esq(); 
       
       if(left <=20 && right <=20 && front <=8) voltar();                               
    
    }
       
    void esq() 
      {
       
        analogWrite(vel_motor_right, 120);
        analogWrite(vel_motor_left, 120);
           
        analogWrite(e1, 0);
        analogWrite(e2, 255);
        analogWrite(d1, 0);
        analogWrite(d2, 255);
        delay(700);      
        
      }
    
    void dir() 
      {
        
      
        analogWrite(vel_motor_right, 120);
        analogWrite(vel_motor_left, 120);
        
        analogWrite(e1, 255);
        analogWrite(e2, 0);
        analogWrite(d1, 255);
        analogWrite(d2, 0);             
        delay(800);
               
      }
    
    void voltar() 
      {
       
        analogWrite(vel_motor_right, 120);
        analogWrite(vel_motor_left, 120);
           
        analogWrite(e1, 255);
        analogWrite(e2, 0);
        analogWrite(d1, 255);
        analogWrite(d2, 0);
        delay(1200); 
         
      }   
  
    
    
    
